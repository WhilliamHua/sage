# Keil uVision project shark.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC (1 DPTR) Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MDU_R515
  output: shark +hex
  AfterMake: D:\Project\windows_app\project-ydxit_3_2_2\branch\proj\Bulid.bat
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../src/: shark.c
